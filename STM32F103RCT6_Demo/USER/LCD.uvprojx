# Keil uVision project LCD.uvprojx, settings and files
target Target 1 (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IRAM(0x20000000,0xC000) IROM(0x08000000,0x40000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: LCD +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,LV_CONF_INCLUDE_SIMPLE
  c include: ..\CORE;..\STM32F10x_FWLib\inc;..\USER;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\HARDWARE\LED;..\HARDWARE\LCD;..\GUI\src;..\GUI;..\GUI\examples\porting;..\GUI\examples\get_started;..\GUI\examples;..\FreeRTOS\include;..\FreeRTOS\portable\RVDS\ARM_CM3
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group USER
    ./: stm32f10x_it.c system_stm32f10x.c main.c
  group HARDWARE
    ../HARDWARE/LED/: led.c
    ../HARDWARE/LCD/: lcd_init.c lcd.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_hd.s
  group FWlib
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group LVGL_SRC
    ../GUI/src/core/: lv_disp.c lv_event.c lv_group.c lv_indev.c lv_indev_scroll.c lv_obj.c lv_obj_class.c lv_obj_draw.c lv_obj_pos.c lv_obj_scroll.c lv_obj_style.c lv_obj_style_gen.c lv_obj_tree.c lv_refr.c lv_theme.c
    ../GUI/src/draw/: lv_draw.c lv_draw_arc.c lv_draw_img.c lv_draw_label.c lv_draw_line.c lv_draw_mask.c lv_draw_rect.c lv_draw_triangle.c lv_img_buf.c lv_img_cache.c lv_img_decoder.c
    ../GUI/src/draw/nxp_pxp/: lv_gpu_nxp_pxp.c lv_gpu_nxp_pxp_osa.c
    ../GUI/src/draw/nxp_vglite/: lv_gpu_nxp_vglite.c
    ../GUI/src/draw/sdl/: lv_draw_sdl.c lv_draw_sdl_arc.c lv_draw_sdl_bg.c lv_draw_sdl_composite.c lv_draw_sdl_img.c lv_draw_sdl_label.c lv_draw_sdl_line.c lv_draw_sdl_mask.c lv_draw_sdl_polygon.c lv_draw_sdl_rect.c lv_draw_sdl_stack_blur.c lv_draw_sdl_texture_cache.c lv_draw_sdl_utils.c
    ../GUI/src/draw/stm32_dma2d/: lv_gpu_stm32_dma2d.c
    ../GUI/src/draw/sw/: lv_draw_sw.c lv_draw_sw_arc.c lv_draw_sw_blend.c lv_draw_sw_dither.c lv_draw_sw_gradient.c lv_draw_sw_img.c lv_draw_sw_letter.c lv_draw_sw_line.c lv_draw_sw_polygon.c lv_draw_sw_rect.c
    ../GUI/src/extra/layouts/flex/: lv_flex.c
    ../GUI/src/extra/layouts/grid/: lv_grid.c
    ../GUI/src/extra/libs/bmp/: lv_bmp.c
    ../GUI/src/extra/libs/ffmpeg/: lv_ffmpeg.c
    ../GUI/src/extra/libs/freetype/: lv_freetype.c
    ../GUI/src/extra/libs/fsdrv/: lv_fs_fatfs.c lv_fs_posix.c lv_fs_stdio.c lv_fs_win32.c
    ../GUI/src/extra/libs/gif/: gifdec.c lv_gif.c
    ../GUI/src/extra/libs/png/: lodepng.c lv_png.c
    ../GUI/src/extra/libs/qrcode/: lv_qrcode.c qrcodegen.c
    ../GUI/src/extra/libs/rlottie/: lv_rlottie.c
    ../GUI/src/extra/libs/sjpg/: lv_sjpg.c tjpgd.c
    ../GUI/src/extra/others/gridnav/: lv_gridnav.c
    ../GUI/src/extra/others/monkey/: lv_monkey.c
    ../GUI/src/extra/others/snapshot/: lv_snapshot.c
    ../GUI/src/extra/themes/basic/: lv_theme_basic.c
    ../GUI/src/extra/themes/default/: lv_theme_default.c
    ../GUI/src/extra/themes/mono/: lv_theme_mono.c
    ../GUI/src/extra/widgets/animimg/: lv_animimg.c
    ../GUI/src/extra/widgets/calendar/: lv_calendar.c lv_calendar_header_arrow.c lv_calendar_header_dropdown.c
    ../GUI/src/extra/widgets/chart/: lv_chart.c
    ../GUI/src/extra/widgets/colorwheel/: lv_colorwheel.c
    ../GUI/src/extra/widgets/imgbtn/: lv_imgbtn.c
    ../GUI/src/extra/widgets/keyboard/: lv_keyboard.c
    ../GUI/src/extra/widgets/led/: lv_led.c
    ../GUI/src/extra/widgets/list/: lv_list.c
    ../GUI/src/extra/widgets/menu/: lv_menu.c
    ../GUI/src/extra/widgets/meter/: lv_meter.c
    ../GUI/src/extra/widgets/msgbox/: lv_msgbox.c
    ../GUI/src/extra/widgets/span/: lv_span.c
    ../GUI/src/extra/widgets/spinbox/: lv_spinbox.c
    ../GUI/src/extra/widgets/spinner/: lv_spinner.c
    ../GUI/src/extra/widgets/tabview/: lv_tabview.c
    ../GUI/src/extra/widgets/tileview/: lv_tileview.c
    ../GUI/src/extra/widgets/win/: lv_win.c
    ../GUI/src/extra/: lv_extra.c
    ../GUI/src/font/: lv_font.c lv_font_dejavu_16_persian_hebrew.c lv_font_fmt_txt.c lv_font_loader.c lv_font_montserrat_8.c lv_font_montserrat_10.c lv_font_montserrat_12.c lv_font_montserrat_12_subpx.c lv_font_montserrat_14.c lv_font_montserrat_16.c lv_font_montserrat_18.c lv_font_montserrat_20.c lv_font_montserrat_22.c lv_font_montserrat_24.c lv_font_montserrat_26.c lv_font_montserrat_28.c lv_font_montserrat_28_compressed.c lv_font_montserrat_30.c lv_font_montserrat_32.c lv_font_montserrat_34.c lv_font_montserrat_36.c lv_font_montserrat_38.c lv_font_montserrat_40.c lv_font_montserrat_42.c lv_font_montserrat_44.c lv_font_montserrat_46.c lv_font_montserrat_48.c lv_font_simsun_16_cjk.c lv_font_unscii_8.c lv_font_unscii_16.c
    ../GUI/src/hal/: lv_hal_disp.c lv_hal_indev.c lv_hal_tick.c
    ../GUI/src/misc/: lv_anim.c lv_anim_timeline.c lv_area.c lv_async.c lv_bidi.c lv_color.c lv_fs.c lv_gc.c lv_ll.c lv_log.c lv_lru.c lv_math.c lv_mem.c lv_printf.c lv_style.c lv_style_gen.c lv_templ.c lv_timer.c lv_tlsf.c lv_txt.c lv_txt_ap.c lv_utils.c
    ../GUI/src/widgets/: lv_arc.c lv_bar.c lv_btn.c lv_btnmatrix.c lv_canvas.c lv_checkbox.c lv_dropdown.c lv_img.c lv_label.c lv_line.c lv_objx_templ.c lv_roller.c lv_slider.c lv_switch.c lv_table.c lv_textarea.c
  group LVGL_PORT
    ../GUI/examples/porting/: lv_port_disp.c lv_port_fs.c lv_port_indev.c
  group LVGL_APP
    ../GUI/examples/widgets/colorwheel/: lv_example_colorwheel_1.c
    ../GUI/examples/libs/gif/: lv_example_gif_1.c
    ../GUI/examples/assets/: leimu_1.c leimu.c
  group FreeRTOS_CORE
    ../FreeRTOS/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
  group FreeRTOS_PORT
    ../FreeRTOS/portable/MemMang/: heap_4.c
    ../FreeRTOS/portable/RVDS/ARM_CM3/: port.c
    ../FreeRTOS/: vApplicationTickHook.c
